Commit message: second commit

File: models/block/model.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- link block: geometry collision box size=0.045 0.045 0.04; visual box size=0.045 0.045 0.04
